# Keil uVision project WAN-Boot.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: WAN-Boot +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\..\src\include\arch_stm32;..\..\src\include\wan_boot;..\..\src\include\lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group arch
    ../../src/arch/: hardware.c Init.c irq.c startup_stm32f10x_hd.s flash_read.c boot_cpu_a.asm
  group wan_boot
    ../../src/wan_boot/: checksum.c cmd.c crc32.c main.c sched.c time.c wanp.c
  group lib
    ../../src/lib/: misc.c printf_to_serial.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
